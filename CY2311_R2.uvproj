# Keil uVision project CY2311_R2.uvproj, settings and files
target CY2311_R2 (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: CY2311_R2 +hex
  AfterMake: ./Tools/srec_cat.exe  @./Tools/Hex2Bin.cmd
  AfterMake: .\Tools\Makefile.cmd
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Includes
  group Source
    ./Source/: main.c protect.c qc.c typec.c updpe.c updphy.c updpm.c updprl.c otp.c otp_default_settings.c PWM.c
    ./Includes/: CAN1110_Configure.h
